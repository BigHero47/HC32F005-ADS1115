# Keil uVision project exe_module.uvprojx, settings and files
target exe_module_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bt_timer
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\mcu\common;..\..\driver\inc;..\master\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../../mcu/common/: system_hc32l110.c
  group master
    ../master/src/: main.c delay_hc.c usart.c ads1115.c usartApp.c
  group driver
    ../../driver/src/: ddl.c interrupts_hc32l110.c clk.c bt.c lpm.c gpio.c uart.c adc.c wdt.c flash.c i2c.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.1.1
